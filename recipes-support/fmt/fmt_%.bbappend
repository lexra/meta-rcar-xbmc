
SRC_URI = "git://github.com/fmtlib/fmt;protocol=http"
